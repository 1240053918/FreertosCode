# Keil uVision project Freertos_Led.uvprojx, settings and files
target freertos_led (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Freertos_Led
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\source;.\freertos\include;.\freertos\portable\RVDS\ARM_CM3;..\freertos-led
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c FreeRTOSConfig.h include.h
  group freertos/source
    ./freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Freertos/Ports
    ./freertos/portable/MemMang/: heap_4.c
    ./freertos/portable/RVDS/ARM_CM3/: port.c portmacro.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
